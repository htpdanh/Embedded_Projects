# Keil uVision project May_ap_trung.uvprojx, settings and files
target May_ap_trung (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: May_ap_trung +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Hardware/Button;../Hardware/CLCD_I2C;../Hardware/DHT;../Hardware/DS18B20;../Hardware/LED7SEG;../Hardware/DS3231;../Hardware/Delaytimer;../Hardware/IR;../Hardware/BUZZER;../Hardware/FAN;../Hardware/HEATER;../App;../Hardware/FLASH
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Hardware
    ../Hardware/Button/: BUTTON.c
    ../Hardware/CLCD_I2C/: CLCD_I2C.c
    ../Hardware/DHT/: DHT.c
    ../Hardware/DS18B20/: DS18B20.c
    ../Hardware/LED7SEG/: LED7SEG.c
    ../Hardware/DS3231/: DS3231.c
    ../Hardware/Delay timer/: delay_timer.c
    ../Hardware/BUZZER/: BUZZER.c
    ../Hardware/FAN/: FAN.c
    ../Hardware/HEATER/: HEATER.c
    ../Hardware/IR/: IR.c
    ../Hardware/FLASH/: FLASH.c
  group Function
    ../Function/: callback.c function.c
  group App
    ../App/: variable.h
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
